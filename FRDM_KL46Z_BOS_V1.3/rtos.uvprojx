# Keil uVision project rtos.uvprojx, settings and files
target KL46Z256 (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtos
  c flags: Optim=1 wLevel=2
  c include: .\src\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group src
    ./src/: board.c main.c
  group arch
    ./src/bos/arch/: context.c
  group drivers
    ./src/bos/drivers/: i2c.c mag3110.c mma8451.c uart.c
  group kernel
    ./src/bos/kernel/: bos_kernel.c bos_timer.c bos_common.c bos_event.c bos_mbx.c
  group util
    ./src/bos/util/: bos_shell.c
  group ::Device
    RTE/Device/MKL46Z256xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
